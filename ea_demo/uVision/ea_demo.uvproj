# Keil uVision project ea_demo.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ea_demo +hex
  c flags: Optim=4
  c include: ..\..\Lib_CMSIS\inc;..\..\Lib_MCU\inc;..\..\Lib_OemBoard\inc;..\..\Lib_OemBaseBoard\inc;..\..\Lib_LPC\inc;..\..\Lib_Displays\inc
  asm define: NO_CRP
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Lib_CMSIS
    ../../Lib_CMSIS/src/: system_LPC177x_8x.c
  group Lib_Displays
    ../../Lib_Displays/src/: ea_lcd_board.c truly_g240320ltsw.c lcd_driver.c lcdb_eeprom.c
  group Lib_LPC
    ../../Lib_LPC/src/: lpc_heap.c lpc_swim.c lpc_swim_image.c lpc_helvr10.c
  group Lib_MCU
    ../../Lib_MCU/src/: lpc177x_8x_adc.c lpc177x_8x_clkpwr.c lpc177x_8x_i2c.c lpc177x_8x_pinsel.c lpc177x_8x_timer.c lpc177x_8x_uart.c lpc177x_8x_dac.c lpc177x_8x_gpdma.c lpc177x_8x_ssp.c
  group Lib_OemBoard
    ../../Lib_OemBoard/src/: sdram.c
  group Lib_OemBaseBoard
    ../../Lib_OemBaseBoard/src/: acc.c board.c joystick.c memreg.c pca9532.c
  group Source Code
    ../src/: main.c demo_image.c lodepng.c speaker.c
    ../../c_keil_uvision/: startup_LPC177x_8x.s
  group Documentation
    ../: readme.txt
