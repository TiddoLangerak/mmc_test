# Keil uVision project eeprom.uvproj, settings and files
target RAM (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: s_eeprom
  c flags: Optim=1 wLevel=2
  c define: __RAM_MODE__
  c include: ..\..\Lib_CMSIS\inc;..\..\Lib_MCU\inc;..\..\Lib_OemBoard\inc;..\..\Lib_OemBaseBoard\inc;..\..\Lib_LPC\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x10008000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Lib_CMSIS
    ../../Lib_CMSIS/src/: system_LPC177x_8x.c
  group Lib_MCU
    ../../Lib_MCU/src/: lpc177x_8x_clkpwr.c lpc177x_8x_i2c.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_adc.c lpc177x_8x_timer.c
  group Lib_OemBoard
    ../../Lib_OemBoard/src/: oem_eeprom.c
  group Lib_OemBaseBoard
    ../../Lib_OemBaseBoard/src/: base_eeprom.c board.c
  group Source Code
    ../src/: main.c
    ../../c_keil_uvision/: startup_LPC177x_8x.s
  group Documentation
    ../: readme.txt
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: s_eeprom +hex
  c flags: Optim=1
  c include: ..\..\Lib_CMSIS\inc;..\..\Lib_MCU\inc;..\..\Lib_OemBaseBoard\inc;..\..\Lib_OemBoard\inc;..\..\Lib_LPC\inc
  asm define: NO_CRP
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
