# Keil uVision project audio.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: s_ob_audio_i2s +hex
  c flags: Optim=1
  c include: ..\..\Lib_CMSIS\inc;..\..\Lib_MCU\inc;..\..\Lib_OemBoard\inc;..\..\Lib_OemBaseBoard\inc;..\..\Lib_LPC\inc
  asm include: ..\common\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Lib_CMSIS
    ../../Lib_CMSIS/src/: system_LPC177x_8x.c
  group Lib_MCU
    ../../Lib_MCU/src/: lpc177x_8x_clkpwr.c lpc177x_8x_i2c.c lpc177x_8x_i2s.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c debug_frmwrk.c
  group Lib_OemBaseBoard
    ../../Lib_OemBaseBoard/src/: uda1380.c
  group Source Code
    ../src/: main.c audiodata.c
    ../../c_keil_uvision/: startup_LPC177x_8x.s
  group Documentation
    ../: readme.txt
