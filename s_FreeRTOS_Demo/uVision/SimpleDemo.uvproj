# Keil uVision project SimpleDemo.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: s_FreeRTOS_Demo +hex
  c flags: Optim=1
  c include: ..\..\Lib_CMSIS\inc;..\..\Lib_MCU\inc;..\..\Lib_FreeRTOS\include;..\..\Lib_FreeRTOS\portable\keil;..\..\Lib_LPC\inc
  asm define: NO_CRP
  asm include: ..\common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Lib_CMSIS
    ../../Lib_CMSIS/src/: system_LPC177x_8x.c
  group Lib_FreeRTOS
    ../../Lib_FreeRTOS/: list.c queue.c tasks.c
    ../../Lib_FreeRTOS/portable/: heap_2.c
    ../../Lib_FreeRTOS/demo_code/: basic_io.c consoleprint.c
  group Source Code
    ../: main.c
    ./: startup_LPC177x_8x.s
    ../../Lib_FreeRTOS/portable/keil/: port.c
  group Documentation
    ../: readme.txt
